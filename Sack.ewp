# IAR project Sack.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; FreeRTOS\include; FreeRTOS\Source; FreeRTOS\Source\MSP430X; minilzo\include; minilzo\Source; bsp; Logcollect\logcollect; ReportForm\ReportForm
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: FreeRTOSConfig.h low_level_init.c main.c RunTimeStatsConfig.c
  group bsp
    bsp/: CLK.c Digitron.c DMA.c PWM_TIMA1.c UART_rs232.c UART_usb.c
  group FreeRTOS_include
    FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS_MSP430X
    FreeRTOS/Source/MSP430X/: data_model.h port.c portext.s43 portmacro.h
  group FreeRTOS_source
    FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    FreeRTOS/Source/MemMang/: heap_1.c
  group Logcollect
    Logcollect/logcollect/: broker.c indexer.c shipper.c strlcpy.c
  group ReportForm
    ReportForm/ReportForm/: FormFormat.c
